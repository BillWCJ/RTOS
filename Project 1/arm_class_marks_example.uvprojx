# Keil uVision project arm_class_marks_example.uvprojx, settings and files
target ARMCM0 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_class_marks_example
  c flags: Optim=1
  c define: ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: arm_class_marks_example_f32.c bst.c bst.h type.h
  group Documentation
    ./: Abstract.txt
target ARMCM3 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_class_marks_example
  c flags: Optim=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4_FP (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_class_marks_example
  c flags: Optim=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM7_SP (ARM-ADS)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_class_marks_example
  c flags: Optim=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1
