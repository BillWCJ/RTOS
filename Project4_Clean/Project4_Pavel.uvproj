# Keil uVision project Project4_Pavel.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project3
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    C:/Software/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
  group Source Code
    ./: Retarget.c uart.c main.c RTX_Conf_CM.c INT0.c LED.c Potentiometer.c KBD.c INT0.h KBD.h LED.h Potentiometer.h GLCD_SPI_LPC1700.c GLCD_Scroll.c
